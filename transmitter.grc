options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: 16qam
  states: {}
- name: quantization
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    label0: Audio file
    label1: Random source
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 2**16-1
    minimum: '0'
    seed: '0'
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test/hallo_test.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: differential_qam_encoder_0
  id: differential_qam_encoder
  parameters:
    order: qam.QAM16
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bits = 8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Short To Byte',
                  in_sig=[np.int16],
                  out_sig=[np.uint8]
              )
              if (n_bits < 1 or n_bits > 8):
                  raise ValueError(f"n_bits must be in range 1..8 (was {n_bits})")
              self.n_bits = n_bits

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0].astype(np.uint16) >> (16 - self.n_bits)).astype(np.uint8)
              return len(output_items[0])
    n_bits: quantization
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '250000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2500010000'
    samplerate: samp_rate*sps
    type: fc32
    uri: ip:pluto-tx.local
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '8'
    gain: '1'
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_pack_k_bits_bb_0, '0', differential_qam_encoder_0, '0']
- [blocks_selector_0, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [differential_qam_encoder_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [epy_block_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
