options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: digital.qam.qam_constellation(2**quantization,True,'gray',True)
  states: {}
- name: fullscreen_select
  id: variable_qtgui_chooser
  parameters:
    label: Fullscreen
    label0: Window
    label1: Fullscreen
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: quantization
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label0: Audio file
    label1: Random source
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 2**16-1
    minimum: '0'
    seed: '0'
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./test/nocturne_e_flat_major_op_9_no_2.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: 2**quantization
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '250000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2500000000'
    samplerate: samp_rate*sps
    type: fc32
    uri: ip:pluto-tx.local
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,4,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,4,1
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '8'
    gain: '1'
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: interp_fir_filter_ccf
  states: {}
- name: short_to_byte_0
  id: short_to_byte
  parameters:
    n_bits: quantization
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      def set_window_mode(fullscreen):
          if fullscreen:
              self.showFullScreen()
          else:
              self.showNormal()

      # Attach function to the instance
      # self.set_window_mode = set_window_mode

      self._fullscreen_select_button_group.buttonClicked[int].connect(
          lambda i: set_window_mode(self._fullscreen_select_options[i])
      )
    section: main_after_init
  states: {}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      from PyQt5 import QtCore
      QtCore.QTimer.singleShot(
          0,
          lambda: (
              self.set_fullscreen_select(self.isFullScreen()),
              print("Fullscreen radio button initialized")
          )
      )
    section: main_after_start
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_selector_0, '0', blocks_short_to_float_0, '0']
- [blocks_selector_0, '0', short_to_byte_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [byte_to_short_0, '0', blocks_short_to_float_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [short_to_byte_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [short_to_byte_0, '0', byte_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
