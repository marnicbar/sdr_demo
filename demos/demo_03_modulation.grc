options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: demo_03_modulation
    output_language: python
    title: 'Demonstration 3: Modulation'
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: digital.qam.qam_constellation(2**quantization,False,'gray',False)
  states: {}
- name: quantization
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,2
    label: Quantization
    label0: '2'
    label1: '4'
    label2: '6'
    label3: '8'
    num_opts: '4'
    option0: '2'
    option1: '4'
    option2: '6'
    option3: '8'
    type: int
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Source selection
    label0: Audio File
    label1: Signal Generator
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,3
    label: Waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: int
    value: '100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 0 if waveform == 100 else 2**15-1 if waveform == 101 or waveform == 102 else 2**16-1
    freq: '440'
    offset: 0 if waveform <= 102 else -2**15
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: waveform
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../audio_examples/nocturne_e_flat_major_op_9_no_2.wav
    offset: 78//2
    repeat: 'True'
    type: short
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,6,5,6
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,0,5,6
    label: dBFS
    legend: 'False'
    name: Audio Spectrum
    norm_window: 'True'
    type: float
    units: ''
    ymax: '0'
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,5,12
    label1: Original
    label2: Quantized
    name: Audio Signal
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: short_to_byte_0
  id: short_to_byte
  parameters:
    n_bits: quantization
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_selector_0, '0', short_to_byte_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_short_to_float_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [byte_to_short_0, '0', blocks_short_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', byte_to_short_0, '0']
- [digital_constellation_encoder_bc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [short_to_byte_0, '0', digital_constellation_encoder_bc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
