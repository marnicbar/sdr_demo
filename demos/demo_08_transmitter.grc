options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: demo_08_transmitter
    output_language: python
    title: 'Demonstration 8: Transmitter'
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: digital.qam.qam_constellation(2**quantization,True,'gray',True)
  states: {}
- name: fullscreen_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,10,1,2
    label: Fullscreen
    label0: Window
    label1: Fullscreen
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: lo_frequency_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,12
    label: LO Frequency Offset
    start: '-20000'
    step: '100'
    stop: '20000'
    value: lo_frequency_offset_init
  states: {}
- name: lo_frequency_offset_init
  id: variable_config
  parameters:
    config_file: gr_config.ini
    option: lo_frequency_offset
    section: transmitter
    type: real
    value: '0'
    writeback: lo_frequency_offset
  states: {}
- name: quantization
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,2
    label: Quantization
    label0: '2'
    label1: '4'
    label2: '6'
    label3: '8'
    num_opts: '4'
    option0: '2'
    option1: '4'
    option2: '6'
    option3: '8'
    type: int
    value: quantization_init
  states: {}
- name: quantization_init
  id: variable_config
  parameters:
    config_file: gr_config.ini
    option: quantization
    section: transmitter
    type: int
    value: '4'
    writeback: quantization
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Source selection
    label0: Audio File
    label1: Random Source
    label2: Signal Generator
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,3
    label: Waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: int
    value: '100'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 2**16-1
    minimum: '0'
    seed: '0'
    type: short
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 0 if waveform == 100 else 2**15-1 if waveform == 101 or waveform == 102 else 2**16-1
    freq: '1000'
    offset: 0 if waveform <= 102 else -2**15
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: waveform
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../audio_examples/nocturne_e_flat_major_op_9_no_2.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: 2**quantization
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '250000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 2450000000 + lo_frequency_offset
    samplerate: samp_rate*sps
    type: fc32
    uri: ip:pluto-tx.local
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,6,5,6
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,0,5,6
    label: dBFS
    legend: 'False'
    name: Audio Spectrum
    norm_window: 'True'
    type: float
    units: ''
    ymax: '0'
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,5,12
    label1: Original
    label2: Quantized
    name: Audio Signal
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '8'
    gain: '2'
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: interp_fir_filter_ccf
  states: {}
- name: short_to_byte_0
  id: short_to_byte
  parameters:
    n_bits: quantization
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      def set_window_mode(fullscreen):
          if fullscreen:
              self.showFullScreen()
          else:
              self.showNormal()

      # Attach function to the instance
      # self.set_window_mode = set_window_mode

      self._fullscreen_select_button_group.buttonClicked[int].connect(
          lambda i: set_window_mode(self._fullscreen_select_options[i])
      )
    section: main_after_init
  states: {}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      from PyQt5 import QtCore
      QtCore.QTimer.singleShot(
          0,
          lambda: (
              self.set_fullscreen_select(self.isFullScreen()),
              print("Fullscreen radio button initialized")
          )
      )
    section: main_after_start
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '2']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_selector_0, '0', blocks_short_to_float_0, '0']
- [blocks_selector_0, '0', short_to_byte_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [byte_to_short_0, '0', blocks_short_to_float_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [short_to_byte_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [short_to_byte_0, '0', byte_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
