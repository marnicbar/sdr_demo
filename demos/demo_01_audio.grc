options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: demo_01_audio
    output_language: python
    title: Demonstrator 1 - Audio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Source selection
    label0: Audio File
    label1: Signal Generator
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,11
    label: Waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: int
    value: '100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 0 if waveform == 100 else 2**15-1 if waveform == 101 or waveform == 102 else 2**16-1
    freq: '440'
    offset: 0 if waveform <= 102 else -2**15
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: waveform
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../audio_examples/nocturne_e_flat_major_op_9_no_2.wav
    offset: '39'
    repeat: 'True'
    type: short
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 2,6,5,6
    label: dBFS
    legend: 'False'
    name: Audio Spectrum
    norm_window: 'True'
    type: float
    units: ''
    ymax: '0'
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,5,6
    legend: 'False'
    name: Audio Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
