options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: demo_07_sync
    output_language: python
    title: 'Demonstration 7: Synchronization'
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: digital.qam.qam_constellation(2**quantization,True,'gray',False)
  states: {}
- name: costas_loop_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,8
    label: Costas Loop Bandwidth
    start: '0.00001'
    step: '0.00001'
    stop: '0.001'
    value: '0.0001'
  states: {}
- name: quantization
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,2
    label: Quantization
    label0: '2'
    label1: '4'
    label2: '6'
    label3: '8'
    num_opts: '4'
    option0: '2'
    option1: '4'
    option2: '6'
    option3: '8'
    type: int
    value: quantization_init
  states: {}
- name: quantization_init
  id: variable_config
  parameters:
    config_file: demo_07.ini
    option: quantization
    section: config
    type: int
    value: '4'
    writeback: quantization
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Source selection
    label0: Audio File
    label1: Signal Generator
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,3
    label: Waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: int
    value: '100'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '0.001'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 0 if waveform == 100 else 2**15-1 if waveform == 101 or waveform == 102 else 2**16-1
    freq: '440'
    offset: 0 if waveform <= 102 else -2**15
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: waveform
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../audio_examples/nocturne_e_flat_major_op_9_no_2.wav
    offset: 78//2
    repeat: 'True'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: byte_to_short_0_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.001'
    freq_offset: '100.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '0.5'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bandwidth
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: 2**quantization
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: 2**quantization
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@0:7,6,5,6
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:7,6,5,6
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0:7,0,5,6
    label: dBFS
    legend: 'False'
    name: Audio Spectrum
    norm_window: 'True'
    type: float
    units: ''
    ymax: '0'
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab@0:2,0,5,12
    label1: Original
    label2: Quantized
    name: Audio Signal
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab@1:2,0,5,12
    legend: 'False'
    name: Audio Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1:7,0,5,6
    name: Baseband Signal
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '8'
    gain: math.sqrt(sps)
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '1'
    gain: math.sqrt(sps)
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: fir_filter_ccf
  states: {}
- name: short_to_byte_0
  id: short_to_byte
  parameters:
    n_bits: quantization
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,10,12
    label0: Transmitter
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: after_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: after_sync
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', byte_to_short_0, '0']
- [blocks_selector_0, '0', blocks_short_to_float_0_1, '0']
- [blocks_selector_0, '0', short_to_byte_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_short_to_float_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_descrambler_bb_0, '0']
- [byte_to_short_0, '0', blocks_short_to_float_0, '0']
- [byte_to_short_0_0, '0', blocks_short_to_float_0_0_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [channels_channel_model_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_skiphead_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_0_0, '0', analog_agc_xx_0, '0']
- [short_to_byte_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [short_to_byte_0, '0', byte_to_short_0_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
