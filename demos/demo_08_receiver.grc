options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: demo_08_receiver
    output_language: python
    title: 'Demonstration 8: Receiver'
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: digital.qam.qam_constellation(2**quantization,True,'gray',True)
  states: {}
- name: costas_loop_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,8
    label: Costas Loop Bandwidth
    start: '0.0001'
    step: '0.0001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: fullscreen_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,10,1,2
    label: Fullscreen
    label0: Window
    label1: Fullscreen
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: lo_frequency_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,12
    label: LO Frequency Offset
    start: '-20000'
    step: '100'
    stop: '20000'
    value: lo_frequency_offset_init
  states: {}
- name: lo_frequency_offset_init
  id: variable_config
  parameters:
    config_file: gr_config.ini
    option: lo_frequency_offset
    section: receiver
    type: real
    value: '0'
    writeback: lo_frequency_offset
  states: {}
- name: quantization
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,8,1,2
    label: Quantization
    label0: '2'
    label1: '4'
    label2: '6'
    label3: '8'
    num_opts: '4'
    option0: '2'
    option1: '4'
    option2: '6'
    option3: '8'
    type: int
    value: quantization_init
  states: {}
- name: quantization_init
  id: variable_config
  parameters:
    config_file: gr_config.ini
    option: quantization
    section: receiver
    type: int
    value: '4'
    writeback: quantization
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '0.01'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bandwidth
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: 2**quantization
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: 2450000000+lo_frequency_offset
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*sps
    type: fc32
    uri: ip:pluto-rx.local
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,6,5,6
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,5,12
    legend: 'False'
    name: Audio Signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,0,5,6
    name: Baseband Signal
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '1'
    gain: '2'
    interp: sps
    ntaps: 11*sps
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: fir_filter_ccf
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      def set_window_mode(fullscreen):
          if fullscreen:
              self.showFullScreen()
          else:
              self.showNormal()

      # Attach function to the instance
      # self.set_window_mode = set_window_mode

      self._fullscreen_select_button_group.buttonClicked[int].connect(
          lambda i: set_window_mode(self._fullscreen_select_options[i])
      )
    section: main_after_init
  states: {}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      from PyQt5 import QtCore
      QtCore.QTimer.singleShot(
          0,
          lambda: (
              self.set_fullscreen_select(self.isFullScreen()),
              print("Fullscreen radio button initialized")
          )
      )
    section: main_after_start
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: after_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: after_sync
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', byte_to_short_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_descrambler_bb_0, '0']
- [byte_to_short_0, '0', blocks_short_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
