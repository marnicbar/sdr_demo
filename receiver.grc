options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: 16qam
  states: {}
- name: quantization
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1000'
    reference: '1.4'
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bits = 8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Byte To Shorts',
                  in_sig=[np.uint8],
                  out_sig=[np.int16]
              )
              if (n_bits < 1 or n_bits > 8):
                  raise ValueError(f"n_bits must be in range 1..8 (was {n_bits})")
              self.n_bits = n_bits

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0].astype(np.uint16) << (16 - self.n_bits)).astype(np.int16)
              return len(output_items[0])
    n_bits: quantization
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2500000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*sps
    type: fc32
    uri: usb:3.8.5
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '4096'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_rolloff
    decim: '1'
    gain: '1'
    interp: sps
    ntaps: 8*32
    samp_rate: sps*samp_rate
    sym_rate: samp_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: after_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: after_sync
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '1', qtgui_number_sink_0, '0']
- [digital_costas_loop_cc_0, '2', qtgui_number_sink_0, '1']
- [digital_costas_loop_cc_0, '3', qtgui_number_sink_0, '2']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_number_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_number_sink_0_0, '1']
- [digital_symbol_sync_xx_0, '3', qtgui_number_sink_0_0, '2']
- [epy_block_1, '0', blocks_short_to_float_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
