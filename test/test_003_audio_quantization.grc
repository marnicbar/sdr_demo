options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: test_003_audio_quantization
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: quantization
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '8'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: 2**(8-quantization)
    type: short
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: 2**(quantization-1)
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/mbaer/projects/projektarbeit_sdr_demo/test/hallo_test.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_short_to_char_0_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_char_to_float_0_0, '0', audio_sink_1_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_short_to_char_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_short_to_char_0_0, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
