options:
  parameters:
    generate_options: qt_gui
    id: test_014_phase_shift
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: descrambler_selector
  id: variable_qtgui_chooser
  parameters:
    label0: No descrambling
    label1: With descrambling
    label2: Multiplicative descrambling
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '1'
  states: {}
- name: quantization
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '8'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: source_selector
  id: variable_qtgui_chooser
  parameters:
    label0: Random source
    label1: Audio file
    label2: Scrambled audio file
    label3: Multiplicative scrambled audio
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '2'
  states: {}
- name: test_constellation
  id: variable_constellation
  parameters:
    const_points: '[3+3j, 1+3j, 1+1j, 3+1j, -3+3j, -3+1j, -1+1j, -1+3j, -3-3j, -1-3j, -1-1j, -3-1j, 3-3j, 3-1j, 1-1j, 1-3j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: calcdist
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 2**16-1
    minimum: '0'
    seed: '0'
    type: short
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: hallo_test.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: '0'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_selector
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: descrambler_selector
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: quantization
  states: {}
- name: differential_qam_decoder_0
  id: differential_qam_decoder
  parameters:
    order: qam.QAM16
  states: {}
- name: differential_qam_encoder_0
  id: differential_qam_encoder
  parameters:
    order: qam.QAM16
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '4'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '""'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_1
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '4'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '""'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: test_constellation
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: test_constellation
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bits = 8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Short To Byte',
                  in_sig=[np.int16],
                  out_sig=[np.uint8]
              )
              if (n_bits < 1 or n_bits > 8):
                  raise ValueError(f"n_bits must be in range 1..8 (was {n_bits})")
              self.n_bits = n_bits

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0].astype(np.uint16) >> (16 - self.n_bits)).astype(np.uint8)
              return len(output_items[0])
    n_bits: quantization
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bits = 8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Short To Byte',
                  in_sig=[np.int16],
                  out_sig=[np.uint8]
              )
              if (n_bits < 1 or n_bits > 8):
                  raise ValueError(f"n_bits must be in range 1..8 (was {n_bits})")
              self.n_bits = n_bits

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0].astype(np.uint16) >> (16 - self.n_bits)).astype(np.uint8)
              return len(output_items[0])
    n_bits: quantization
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bits = 8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Byte To Shorts',
                  in_sig=[np.uint8],
                  out_sig=[np.int16]
              )
              if (n_bits < 1 or n_bits > 8):
                  raise ValueError(f"n_bits must be in range 1..8 (was {n_bits})")
              self.n_bits = n_bits

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0].astype(np.uint16) << (16 - self.n_bits)).astype(np.int16)
              return len(output_items[0])
    n_bits: quantization
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: after_channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: after_channel
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_random_uniform_source_x_0, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', epy_block_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_selector_0, '3']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_selector_1, '2']
- [blocks_phase_shift_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', differential_qam_encoder_0, '0']
- [blocks_selector_1, '0', epy_block_1, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_descrambler_bb_0, '0']
- [differential_qam_decoder_0, '0', blocks_selector_1, '0']
- [differential_qam_decoder_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [differential_qam_decoder_0, '0', digital_additive_scrambler_xx_1, '0']
- [differential_qam_encoder_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_additive_scrambler_xx_0, '0', blocks_selector_0, '2']
- [digital_additive_scrambler_xx_1, '0', blocks_selector_1, '1']
- [digital_constellation_decoder_cb_0, '0', differential_qam_decoder_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_phase_shift_0, '0']
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [epy_block_0, '0', blocks_selector_0, '0']
- [epy_block_0_0, '0', blocks_selector_0, '1']
- [epy_block_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [epy_block_0_0, '0', digital_additive_scrambler_xx_0, '0']
- [epy_block_1, '0', blocks_short_to_float_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
