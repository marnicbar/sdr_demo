options:
  parameters:
    author: mbaer
    generate_options: qt_gui
    id: test_003_audio_quantization_custom
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: quantization
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '8'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: hallo_test.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: byte_to_short_0
  id: byte_to_short
  parameters:
    n_bits: quantization
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: short_to_byte_0
  id: short_to_byte
  parameters:
    n_bits: quantization
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_0, '0', short_to_byte_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_1_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [byte_to_short_0, '0', blocks_short_to_float_0, '0']
- [short_to_byte_0, '0', byte_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
