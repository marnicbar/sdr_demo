options:
  parameters:
    generate_options: qt_gui
    id: audio_modulated_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: quantization
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '8'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: test_constellation
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: 16qam
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 2**(8-quantization)
    type: short
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 2**(quantization-1)
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mbaer/projects/projektarbeit_sdr_demo/test/hallo_test.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: test_constellation
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: test_constellation
    maxoutbuf: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '8'
    gain: '1'
    interp: '8'
    ntaps: 8*32
    samp_rate: 8*samp_rate
    sym_rate: samp_rate
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '8'
    gain: '1'
    interp: '8'
    ntaps: 8*32
    samp_rate: 8*samp_rate
    sym_rate: samp_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [blocks_char_to_float_0, '0', audio_sink_1, '0']
- [blocks_divide_xx_0, '0', blocks_short_to_char_0, '0']
- [blocks_file_source_0, '0', blocks_divide_xx_0, '0']
- [blocks_short_to_char_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
